ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAX
HERE: SJMP HERE
ORG 130H
MAX:
MOV R0,#60H
MOV R1,#61H
MOV R2,#8

MOV A,@R0

FORWARD: DJNZ R2, LOOP
JMP HERE
LOOP: 
MOV R3,A
SUBB A, @R1
JNC NEW
MOV A,@R1
INC R1
MOV 70H,A
JMP FORWARD
NEW:
MOV A,R3
INC R1
MOV 70H,A
JMP FORWARD

RET
END