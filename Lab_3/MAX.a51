ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAX
HERE: SJMP HERE
ORG 130H
MAX:
MOV R0,#8
MOV R1,60H
MOV R2,61H

MOV A,R1
FORWARD: DJNZ R0,LOOP
LOOP: SUBB A,R2
JC NEW
MOV A,R2
INC R2
MOV 70H,A
JMP FORWARD
NEW:
MOV A,R1
INC R2
MOV 70H,A
JMP FORWARD

RET
END